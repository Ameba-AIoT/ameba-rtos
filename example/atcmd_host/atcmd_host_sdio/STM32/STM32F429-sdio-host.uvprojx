# Keil uVision project STM32F429-sdio-host.uvprojx, settings and files
target ATCMD_SDIO_HOST (6220000::V6.22::ARMCLANG)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F429
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,DEBUG ,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c include: ..\..\User;..\..\User\usart;..\..\User\include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\FreeRTOS\ver9.0.0\Source\include;..\..\Libraries\FreeRTOS\ver9.0.0\Source;..\..\Libraries\FreeRTOS\ver9.0.0\Source\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DOC
    ../../: 必读说明.txt
  group USER
    ../../User/: stm32f4xx_it.c stm32_dplus_main.c wwd_SDIO.c sdio_host_stm32_hal.c sdio_api_ext.c
    ../../User/usart/: usart.c
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_dma.c misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_qspi.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group FreeRTOS-Source
    ../../Libraries/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS-Source-portable
    ../../Libraries/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_4.c
    ../../Libraries/FreeRTOS/ver9.0.0/Source/portable/GCC/ARM_CM3/: port.c
